options:
  parameters:
    author: Mangal
    generate_options: qt_gui
    id: wav_amplitude_modulation
    output_language: python
    title: 'audio '
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '300000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_2
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\saman\Downloads\y2mate-com-metamorphosis-ringtone-download-link-60514.wav
    repeat: 'False'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '22000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '5'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color1: '"green"'
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    label1: modulated signal - U(f)
    type: float
  states: {}
- name: qtgui_freq_sink_x_3
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color1: '"black"'
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    label1: demodulated signal - U'(f)
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    color1: green
    ctrlpanel: 'True'
    label1: modulated signal - u(t)
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    color1: black
    ctrlpanel: 'True'
    label1: demodulated signal - u'(t)
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_const_source_x_1, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_2, '1']
- [blocks_add_xx_0, '0', blocks_multiply_xx_1, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_1, '0', blocks_multiply_xx_2, '0']
- [blocks_multiply_xx_1, '0', qtgui_freq_sink_x_1, '0']
- [blocks_multiply_xx_1, '0', qtgui_time_sink_x_2, '0']
- [blocks_multiply_xx_2, '0', low_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_xx_0, '1']
- [low_pass_filter_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_3, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_3, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
